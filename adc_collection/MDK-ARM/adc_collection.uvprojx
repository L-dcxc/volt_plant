# Keil uVision project adc_collection.uvprojx, settings and files
target adc_collection (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2000BFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: adc_collection +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../mycode
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c rtc.c sdmmc.c spi.c tim.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_mmc.c stm32l4xx_hal_mmc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group mycore
    ../mycode/: ad7124.c storage.c app_rtc.c app_config.c eeprom.c app_config_store.c modbus_rtu.c app_modbus.c ad7124_config.c recorder.c file_browser.c ymodem.c battery.c control_outputs.c
software components: CMSIS:CORE 4.3.0
